# Keil uVision project HID_Read.uvprojx, settings and files
target File (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HIDV10 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\USER\inc;..\thm3070;..\secure;..\3DES;..\CMSIS;..\ETH\inc;..\lwip-1.3.1\port;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\FWlib\inc;..\USER\inc;..\usb_library\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/src/: stm32f10x_it.c UASRT.c GPIOx.c delay.c main.c TIM.c sys.c SPI.c netconf.c stm32f107.c TCPClient.c usart.c
    ../lwip-1.3.1/port/: client.c server.c
  group secure
    ../secure/: secure.c
  group ETH
    ../ETH/src/: stm32_eth.c
  group LwIP
    ../lwip-1.3.1/src/netif/: etharp.c ethernetif.c
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group FWLIB
    ../FWlib/src/: stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
